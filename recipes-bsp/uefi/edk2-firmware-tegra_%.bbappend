FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-L4TLauncher-Add-Xen-Multiboot2-support.patch;patchdir=../edk2-nvidia"
