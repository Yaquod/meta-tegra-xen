FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0002-QSPI-SPI-controller-spi-3270000-.-The-QSPI-driver-sp.patch"

