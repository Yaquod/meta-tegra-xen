PACKAGECONFIG:append = " virglrenderer opengl xen"
EXTRA_OECONF:append = " --enable-virglrenderer --enable-opengl --enable-xen"