# Fix neatvnc to use actual 0.8.1 release
SRCREV = "55566b5176de4bb18e0af0d906555bf77c58fa93"
